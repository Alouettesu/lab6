# IAR project armasm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Application\inc; ..\drivers\include; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\portable\IAR\LPC2000
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\FreeRTOS\Source\include; ..\Application\inc
  OBJCOPY.OOCOutputFile: armasm.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\armasm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: NDEBUG
  group Application/inc
    ../Application/inc/: app_config.h FreeRTOSConfig.h mini-printf.h print.h receive.h stat.h
  group Application/src
    ../Application/src/: init.c main.c print.c receive.c sections_init.c
    ../Application/: startup.s
  group driver
    ../drivers/: interrupt.c timer.c uart.c
  group FreeRTOS/inc
    ../FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../FreeRTOS/Source/portable/IAR/LPC2000/: tick_timer_settings.h
  group FreeRTOS/MemMang
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FreeRTOS/port/inc
    ../FreeRTOS/Source/portable/IAR/LPC2000/: ISR_Support.h portmacro.h
  group FreeRTOS/port/src
    ../FreeRTOS/Source/portable/IAR/LPC2000/: port.c portasm.s79 portISR.c
  group FreeRTOS/src
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
