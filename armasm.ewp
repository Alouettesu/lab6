# IAR project armasm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: Application; drivers\include; FreeRTOS\Source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: armasm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: asm.s main.c
  group Application
    Application/: init.c main.c mini-printf.c nostdlib.c print.c receive.c stf_syscalls_minimal.c
  group driver
    drivers/: interrupt.c timer.c uart.c
